# Keil uVision project WDJ.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H4K64TLR Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x0FFF) IROM(0-0xFFF8) CLOCK(45000000) MODP2
  output: WDJ +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./src/: ADC.c ADC.h Delay.c Delay.h DigitLED.c DigitLED.h DS18B20.c DS18B20.h main.c PWM.c STARTUP.A51 STC8H.h Timer.c Timer.h TouchKey.c TouchKey.h UART.c UART.h IIC.c IIC.h IAP.c IAP.h PWM.h main.h
